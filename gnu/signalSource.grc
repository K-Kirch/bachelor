options:
  parameters:
    generate_options: qt_gui
    id: signalSource
    output_language: python
    title: FM Radio P3
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 92e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: '40'
    samp_rate: samp_rate
    type: fc32
    vga: '40'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
