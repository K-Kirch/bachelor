options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(100000)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/kristian/Desktop/transmission.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kristian/Desktop/transmission.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 1, 1, 1, 1, 1)
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: '2'
    sensitivity: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: 1024*16
    nrows: '1'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
    vga: '0'
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_demod_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
