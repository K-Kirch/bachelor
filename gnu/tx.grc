options:
  parameters:
    author: kristian
    generate_options: qt_gui
    id: tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 438e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kristian/Desktop/BachelorProject/msg.txt
    repeat: 'True'
    type: float
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '2'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '400'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Random import get_random_bytes


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, key = b'', iv = b'', mode = AES.MODE_CBC, key_size = 16, block_size = AES.block_size, padding = b'\0', **kwargs):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AES Encrypt',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.key = key
              self.iv = iv
              self.mode = mode
              self.key_size = key_size
              self.block_size = block_size
              self.padding = padding

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # Generate a random key
              self.key = get_random_bytes(self.key_size)
              
              # Pad the message
              p_msg = input_items + b'\0' * (AES.block_size - len(self.key) % AES.block_size)

              # Create a cipher object
              cipher = AES.new(self.key, AES.MODE_CBC)

              # Encrypt the message
              output_items = cipher.encrypt(p_msg)
              return self.key, output_items
    block_size: '16'
    iv: b''
    key: b''
    key_size: '16'
    mode: '2'
    padding: b'\x00'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from reedsolo import RSCodec


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, message = b'', rsc = RSCodec(10)):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Reed-Solomon Encoding',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message = message
              self.rsc = rsc

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              enc_msg = self.rsc.encode(input_items)
              return enc_msg
    message: ''
    rsc: ''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e3
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']
- [digital_psk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_psk_mod_0, '0', soapy_hackrf_sink_1, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', digital_psk_mod_0, '0']

metadata:
  file_format: 1
