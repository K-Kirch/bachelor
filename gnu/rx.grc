options:
  parameters:
    author: kristian
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 48.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Random import get_random_bytes


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, key = b'', iv = b'', mode = AES.MODE_CBC, key_size = 16, block_size = AES.block_size, padding = b'\0', **kwargs):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AES Decrypt',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.key = key
              self.iv = iv
              self.mode = mode
              self.key_size = key_size
              self.block_size = block_size
              self.padding = padding

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # Generate a random key
              self.key = get_random_bytes(self.key_size)
              
              # Create a cipher object
              cipher = AES.new(self.key, AES.MODE_CBC)

              # Encrypt the message
              decrypt_msg = cipher.encrypt(input_items)

              #Unpad message
              output_items = decrypt_msg.rstrip(b'\0')

              return output_items
    block_size: '16'
    iv: b''
    key: b''
    key_size: '16'
    mode: '2'
    padding: b'\x00'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    differential: 'False'
    f_offset: '0'
    iq: 'True'
    manchester: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [digital_psk_demod_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', digital_psk_demod_0, '0']
- [soapy_hackrf_source_0, '0', satellites_bpsk_demodulator_0, '0']

metadata:
  file_format: 1
